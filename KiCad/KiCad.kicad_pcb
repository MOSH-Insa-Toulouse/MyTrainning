# Repository MOSH-Insa-Toulouse/MyTrainning

File README.md:

# My Trainning

My first project with KiCad...

<!-- Syntaxe Markdown: https://learnxinyminutes.com/docs/fr-fr/markdown-fr/ -->

## Here is my schema

## Here is my Arduino shield for my gas sensor

<!-- You can also add images with simple HTML tags: -->

## And a part of importante code

```c
/* on Arduino Uno */
#define OFF 0
#define ON 1
#define T_REGENERATION_MS 2500 // 2.5 sec for regeneration delay
...
    // somewhere in the state machine
    if ( isRgazSensorSaturated() ) {
        // if the gas sensor saturated do
        setRregeneration(ON);
        delay(T_REGENERATION_MS) // wait for the necessary time, see https://www.arduino.cc/reference/en/#functions
        setRregeneration(OFF);
    }
...

```

## MIT license

## KiCad design KiCad/KiCad.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 8 parts (0 on the bottom side), 3 nets, no tracks yet.

Parts:
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin

Connections:
/A4(SDA): P2.5, P3.2
/A5(SCL): P2.6, P3.1
GND: P1.6, P1.7, P3.4

## Commit log

2018-10-02 Add KiCad new project
2018-11-09 Add license picture in README.md
2019-12-11 Presentation of the deliverable
2019-12-11 Update path to pictures
2019-12-11 New path update
2019-12-11 Add html syntaxe for add image in Markdown
